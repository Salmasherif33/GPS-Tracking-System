# Keil uVision project est2.uvproj, settings and files
target Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: est2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MAIN
    ./: startup_TM4C123.s main.c
  group GPIO
    ./: GPIO.c
  group DISTANCE
    ./: disance.c
  group SYSICK
    ./: systick.c
  group UART0
    ./: uart.c
  group Lcd
    ./: lcd.c
  group GPScutting
    ./: GPScutting.c
  group UART2
    ./: uart2.c
